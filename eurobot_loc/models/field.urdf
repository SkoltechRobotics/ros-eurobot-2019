Commit message: test differenet constraints

File: eurobot_loc/models/field.urdf (robot description, URDF)
Before this commit: robot field, 2 links, 1 joints
Links:
- link table: geometry visual mesh filename=package://eurobot_loc/models/tableold.STL
